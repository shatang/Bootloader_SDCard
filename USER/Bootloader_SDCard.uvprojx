# Keil uVision project Bootloader_SDCard.uvprojx, settings and files
target Bootlader_SDCard (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Shatang +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\FATFS\exfuns;..\FATFS\src;..\MALLOC;..\Board_Support_Package\SDIO;..\Board_Support_Package\Timer;..\Board_Support_Package\LED;..\IAP_SDCard
  memory RVCT4: ROM 0x8000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group SYSTEM
    ../SYSTEM/sys/: sys.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_tim.c stm32f4xx_dma.c
  group BSP
    ../Board_Support_Package/SDIO/: sdio_sdcard.c
    ../Board_Support_Package/Timer/: Timer_Driver.c
    ../Board_Support_Package/LED/: Led_Driver.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c mycc936.c
  group IAP_SDCard
    ../IAP_SDCard/: download.c flash_if.c
  group README
    ../: readme.txt
